# Keil uVision project Project.uvprojx, settings and files
target Target 1 (6180000::V6.18::ARMCLANG)
  device: TM4C123GH6PM Texas Instruments
  pack: Keil.TM4C_DFP.1.1.0
  cpu: IRAM(0x20000000,0x008000) IROM(0x00000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\COTS\LIB;.\COTS\MCAL\MGPIO;.\COTS\MCAL\MINT;.\COTS\MCAL\MSYSCLK;.\COTS\MCAL\MSYSTICK;.\COTS\HAL\HLED;.\COTS\HAL\HSWITCH
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x8000
  group MCAL
    ./COTS/MCAL/MGPIO/: MGPIO_Program.c
    ./COTS/MCAL/MINT/: MINT_Program.c
    ./COTS/MCAL/MSYSCLK/: MSYSCLK_Program.c
    ./COTS/MCAL/MSYSTICK/: MSYSTICK_Program.c
  group APP
    ./COTS/APP/: APP_LedBlink.c
  group HAL
    ./COTS/HAL/HLED/: HLED_Program.c
    ./COTS/HAL/HSWITCH/: HSWITCH_Program.c
software components: CMSIS:CORE 5.6.0, Device:Startup 1.0.1
